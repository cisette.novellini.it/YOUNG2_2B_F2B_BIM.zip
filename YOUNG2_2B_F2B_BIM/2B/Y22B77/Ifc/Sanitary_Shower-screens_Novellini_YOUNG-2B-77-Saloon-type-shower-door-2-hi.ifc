Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Shower-screens_Novellini_YOUNG-2B-77-Saloon-type-shower-door-2-hi.ifc
Time: 2020-07-09T13:54:20
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcProxy, YOUNG 2B 77 - Saloon type shower door - 2 hinged doors
ePset_BIMobjectScript - Door Panel Material: Clear; Door Frame Material: Silver_B; LOD: 300; Door Width: 0.00077
ePset_BIMobject_BO - ProductName (BO_prodinfo): YOUNG 2B 77 - Saloon type shower door - 2 hinged doors; SKU (BO_prodsku): Y22B77; ManufacturName (BO_Manufac): Novellini; BrandUrl (BO_brandurl): https://www.novellini.co.uk/; ProductFamily (BO_prodfam): YOUNG; ProductGroup (BO_prodgroup): YOUNG 2B; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 2000; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/novellini/product/Y22B77; ProductDataUrl (BO_prodaturl): bimobject.com/novellini/product/Y22B77; ProductUrl (BO_producturl): https://www.novellini.com/content/com/int/en/collections/shower-enclosures/young/young-2b-f.html; InstallationInstructions (BO_montins): https://www.novellini.com/content/dam/novellini-archive/Pdf_Montaggio/box/young20/60095DY2%20Young2%202B/60095DY2_04%20Young2%202B.pdf; TechnicalDescription (BO_techcert): https://www.novellini.com/content/dam/novellini-archive/Pdf_Scheda/NOVELLINI/2019/int/YOUNG2B-2019-INT.pdf; MaterialMain (BO_mainmat): Glass; MaterialSecondary (BO_secmat): Aluminium; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Shower screens; BimObjectCategoryCode (BO_bocat_code): sanitary-shower-screens; IfcClassification (BO_ifcclas): Object; UnspscCode (BO_unspsc): 30181507; Uniclass14Code (BO_uniclass_1_4_code): L72118; Uniclass14Description (BO_uniclass_1_4_desc): Bath screens, curtains; Uniclass20Code (BO_uniclass_2_0_code): PR-31-06; Uniclass20Description (BO_uniclass_2_0_desc): Bathing Fittings; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_76_07; Uniclass2015Description (BO_uniclass2015_desc): Bath panels; NBSReference (BO_nbs_ref): 31-06; NBSReferenceDescription (BO_nbs_desc): Bathing Fittings; OmniClassCode (BO_omniclass_code): 23-31 17 17; OmniClassDescription (BO_omniclass_name): Shower Enclosures; MasterFormat2014Code (BO_masterformat2014_code): 12 35 30.23; MasterFormat2014Description (BO_masterformat2014_name): Bathroom Casework; UniFormat2Code (BO_uniformat2_code): C1030; UniFormat2Description (BO_uniformat2_name): Fittings; RegionEurope (BO_europe): AT, BA, BE, BG, CH, CZ, DE, ES, FR, GB, GR, HR, HU, IT, LT, LU, ME, NL, NO, PL, RO, RU, SI, SK, UA
